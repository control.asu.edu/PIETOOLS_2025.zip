classdef PIETOOLS_PDE_GUI < matlab.apps.AppBase

    % Properties that correspond to app components
    properties (Access = public)
        PIETOOLSUIFigure              matlab.ui.Figure
        GridLayout                    matlab.ui.container.GridLayout
        LeftPanel                     matlab.ui.container.Panel
        ConverttoPIEButton            matlab.ui.control.Button
        Step5ConvertPDEtoPIELabel     matlab.ui.control.Label
        AddnewBCButton                matlab.ui.control.Button
        RemoveBCButton                matlab.ui.control.Button
        RemoveBCList                  matlab.ui.control.DropDown
        Step3OptionalAddorRemoveBCLabel  matlab.ui.control.Label
        GetPDEObjectButton            matlab.ui.control.Button
        Step4ParsePDEparametersLabel  matlab.ui.control.Label
        Step2aDefinetermtoaddtoequationinStep2Label  matlab.ui.control.Label
        Step2SelectanequationtoaddatermLabel  matlab.ui.control.Label
        SelecttermtypeandthendefinethetermPanel  matlab.ui.container.Panel
        Label_3                       matlab.ui.control.Label
        TermtobeaddedLabel            matlab.ui.control.Label
        AddButton                     matlab.ui.control.Button
        TermTypeLabel                 matlab.ui.control.Label
        d_sLabel                      matlab.ui.control.Image
        intLabel                      matlab.ui.control.Image
        derivativeOrder               matlab.ui.control.NumericEditField
        intUpperLimit                 matlab.ui.control.DropDown
        intLowerLimit                 matlab.ui.control.DropDown
        IndepVar                      matlab.ui.control.DropDown
        Label_2                       matlab.ui.control.Label
        Label                         matlab.ui.control.Label
        IntVariable                   matlab.ui.control.DropDown
        TermType                      matlab.ui.control.DropDown
        ProductList                   matlab.ui.control.DropDown
        Coefficient                   matlab.ui.control.EditField
        SelectanequationtypeandthenselecttheequationPanel  matlab.ui.container.Panel
        EquationNumberLabel           matlab.ui.control.Label
        EquationTypeLabel             matlab.ui.control.Label
        ButtonGroup                   matlab.ui.container.ButtonGroup
        BCButton                      matlab.ui.control.ToggleButton
        OutputButton                  matlab.ui.control.ToggleButton
        DynamicsButton                matlab.ui.control.ToggleButton
        LHSDropDown_output            matlab.ui.control.DropDown
        LHSDropDown_BC                matlab.ui.control.DropDown
        LHSDropDown_Dyn               matlab.ui.control.DropDown
        CenterPanel                   matlab.ui.container.Panel
        StatusBox                     matlab.ui.control.Label
        StatusPanel                   matlab.ui.container.Panel
        Eqns                          matlab.ui.control.UIAxes
        RightPanel                    matlab.ui.container.Panel
        SavePDEorLoadpreviouslysavedPDEPanel  matlab.ui.container.Panel
        LoadButton                    matlab.ui.control.Button
        SaveButton                    matlab.ui.control.Button
        Step1DefineStatesOutputsandInputsLabel  matlab.ui.control.Label
        RedoButton                    matlab.ui.control.Button
        UndoButton                    matlab.ui.control.Button
        VarTable                      matlab.ui.control.Table
        RemoveButton                  matlab.ui.control.Button
        VarType                       matlab.ui.control.DropDown
        AddVar                        matlab.ui.control.Button
        TextArea                      matlab.ui.control.TextArea
        ContextMenu                   matlab.ui.container.ContextMenu
        helpAddNewBC                  matlab.ui.container.Menu
    end

    % Properties that correspond to apps with auto-reflow
    properties (Access = private)
        onePanelWidth = 576;
        twoPanelWidth = 768;
    end

    
    methods (Access = public)
        
        function null = loadData(app,data)
            if ~isfield(data,'vars')||~isfield(data,'varheaders')||...
                    ~isfield(data,'eqns')||~isfield(data,'eqnheaders')
                null=1;
                return
            end
            %reset panels on the left
            dummyOut = app.resetLeftPanel;
            set(app.VarTable,'Data',data.vars);
            set(app.VarTable,'UserData',data.varheaders);
            set(app.TextArea,'Value',data.eqns);
            set(app.TextArea,'UserData',data.eqnheaders);
            
%             BClist = {};
            
%             nBC = length(data.eqns)-data.eqnheaders(end); 
%             for i=1:nBC
%                 BClist{1,end+1} = num2str(i);
%             end
%             set(app.LHSDropDown_BC, 'Items', BClist);
%             set(app.RemoveBCList, 'Items', BClist);
            
            removeStyle(app.VarTable);
            boldStyle = uistyle('FontWeight','bold');
            addStyle(app.VarTable,boldStyle,'cell',[data.varheaders.headerLoc;[data.varheaders.headerLoc(1,1) 2]]);
            
            dummyOut = app.updateDisplay(data.eqns,data.eqnheaders);
            
            null=0;
        end
    end
    
    methods (Access = private)
        
        function logval = updateDisplay(app,textDyn,locData)
            textDyn=erase(textDyn,'*');
            k=1;
            for i=1:length(textDyn)
                if ~ismember(locData,i)
                    tmptext = textDyn{i};
                    textDyn{i} = ['$',num2str(k),')\quad ', tmptext(2:end)];
                    rowNum(i) = k;
                    k=k+1;
                else
                    rowNum(i) = 0;
                end
            end
            setappdata(app.PIETOOLSUIFigure,'EqnNum',rowNum);
            cla(app.Eqns);
            text(app.Eqns,0,1,textDyn,'VerticalAlignment','top','interpreter','latex');
            logval=0;
        end
        
        function dummy = resetLeftPanel(app)
            % reset step 2a components
            set(app.TermType,'Value',' ');
            
            set(app.Coefficient,'Visible','off');
            set(app.Coefficient,'Value','1');
            
            set(app.ProductList,'Visible','off');
            set(app.ProductList, 'Items', {' '});
            
            set(app.intLabel,'Visible','off');
            set(app.intLowerLimit,'Visible','off');
            set(app.intUpperLimit,'Visible','off');
            set(app.IntVariable,'Visible','off');
            
            set(app.d_sLabel,'Visible','off');
            set(app.derivativeOrder,'Visible','off');
            set(app.derivativeOrder,'Value',0);
            
            set(app.IndepVar,'Visible','off');
            set(app.Label, 'Visible','off');
            set(app.Label_2, 'Visible','off');
            set(app.Label_3, 'Visible', 'off');
            
            % reset step 2 components
            set(app.ButtonGroup.Buttons(1,4),'Value',1);
            set(app.LHSDropDown_Dyn,'Visible', 'off');
            set(app.LHSDropDown_Dyn, 'Items', {' '});
            set(app.LHSDropDown_output,'Visible', 'off');
            set(app.LHSDropDown_output, 'Items', {' '});
            set(app.LHSDropDown_BC,'Visible', 'off');
            
            dummy=0;
        end
        
        function dummy = updateUndoStack(app)
            previousStates = get(app.UndoButton,'UserData');
            previousStates(1:end-1) = previousStates(2:end); %erase furthest history
           
            tmp.vars = get(app.VarTable,'Data');
            tmp.varheaders = get(app.VarTable,'UserData');
            tmp.eqns = get(app.TextArea, 'Value');
            tmp.eqnheaders = get(app.TextArea, 'UserData');
            tmp.EqnNum = getappdata(app.PIETOOLSUIFigure,'EqnNum');
            
            previousStates{end} = tmp; % store current state
            set(app.UndoButton,'UserData',previousStates);
            
            dummy=0;
        end
        
        
        function dummy = updateRedoStack(app)
            futureStates = get(app.RedoButton,'UserData');
            %push current state into future state for ReDo option
            futureStates(2:end) = futureStates(1:end-1); % erase furthestmost future
            tmp.vars = get(app.VarTable,'Data');
            tmp.varheaders = get(app.VarTable,'UserData');
            tmp.eqns = get(app.TextArea, 'Value');
            tmp.eqnheaders = get(app.TextArea, 'UserData');
            tmp.EqnNum = getappdata(app.PIETOOLSUIFigure,'EqnNum');
            
            futureStates{1} = tmp;
            set(app.RedoButton,'UserData',futureStates);
            
            dummy=0;
        end
    end
    

    % Callbacks that handle component events
    methods (Access = private)

        % Code that executes after component creation
        function InitializeGUI(app)
            if ~any(ismember(fieldnames(app.LHSDropDown_Dyn),'DropDownOpeningFcn'))
                Str1 = 'PIETOOLS PDE GUI is compatible only with app designer of MATLAB 2021a or later.';
                Str2 = 'Since the GUI was opened in earlier version of app designer, the file is irreversibly modified and hence non functional.';
                Str3 = 'Please redownload the GUI file and do not open using app designer to use the GUI.';
                errordlg([Str1,' ',Str2,' ', Str3],'modal');
            end
            
            guiPath = [cd,filesep,'GUI']; % get path for GUI elements
            addpath(genpath(guiPath)); % add GUI subfolders to the path
            
            %reload image if path changed
            app.intLabel.ImageSource = 'integral_symbol.png';
            app.d_sLabel.ImageSource = 'partial_symbol.png';
            
            boldStyle = uistyle('FontWeight','bold');
            VarTypes = {'PDE State:', 'Highest Spatial Derivative:'; 
                         'ODE State:', ''
                         'Disturbance Input:', ''
                         'Control Input:', ''
                         'Regulated Output:', ''
                         'Observed Output:', ''};
            set(app.VarTable,'Data',VarTypes);
            addStyle(app.VarTable,boldStyle, 'cell',[1,1;1,2;2,1;3,1;4,1;5,1;6,1]);
            datatmp = struct('headerLoc', [1,1;2,1;3,1;4,1;5,1;6,1], 'SelectCell',[]);
            set(app.VarTable,'UserData',datatmp);
            set(app.StatusBox,'Text', ' ');


            initEqns = {'$\textbf{PDE Dynamics:}$';'$\textbf{ODE Dynamics:}$';...
                '$\textbf{Regulated Output:}$'; '$\textbf{Observed Output:}$'; '$\textbf{Boundary Conditions:}$'};
            locs = [1;2;3;4;5];
            set(app.TextArea,'Value',initEqns);
            set(app.TextArea,'UserData',locs);
            
            
            dummyOut = app.updateDisplay(initEqns,locs);
              
            for i=1:10
                tmp{i}.vars = get(app.VarTable,'Data');
                tmp{i}.varheaders = get(app.VarTable,'UserData');
                tmp{i}.eqns = get(app.TextArea, 'Value');
                tmp{i}.eqnheaders = get(app.TextArea, 'UserData');
                tmp{i}.EqnNum = getappdata(app.PIETOOLSUIFigure,'EqnNum');
            end
            
            set(app.UndoButton,'UserData',tmp);
            tmp = cell(1,10);
            set(app.RedoButton,'UserData',tmp);
            
            NULLButton = uitogglebutton(app.ButtonGroup);
            NULLButton.Text = 'None';
            NULLButton.Position = [11 90 100 22];
            NULLButton.Visible = 'off';
            NULLButton.Value = true;
            
            dummyOut = app.resetLeftPanel;
            
            app.IntVariable.Items = {'ds', ['d',char(0x03B8)], '0', '1'};
            app.IndepVar.Items = {'s', [char(0x03B8)], '0', '1'}; 
            if ~any(ismember(fieldnames(app.LHSDropDown_Dyn),'DropDownOpeningFcn'))|| isempty(app.LHSDropDown_Dyn.DropDownOpeningFcn)
                Str1 = 'PIETOOLS PDE GUI is compatible only with app designer of MATLAB 2021a or later.';
                Str2 = 'Since the GUI was opened in earlier version of app designer, the file is irreversibly modified and hence non functional.';
                Str3 = 'Please redownload the GUI file and do not open using app designer to use the GUI.';
                tmp = errordlg([Str1,' ',Str2,' ', Str3],'Error', 'modal');
                uiwait(tmp);
            end
            
            app.PIETOOLSUIFigure.Name = 'PIETOOLS';
        end

        % Changes arrangement of the app based on UIFigure width
        function updateAppLayout(app, event)
            currentFigureWidth = app.PIETOOLSUIFigure.Position(3);
            if(currentFigureWidth <= app.onePanelWidth)
                % Change to a 3x1 grid
                app.GridLayout.RowHeight = {631, 631, 631};
                app.GridLayout.ColumnWidth = {'1x'};
                app.CenterPanel.Layout.Row = 1;
                app.CenterPanel.Layout.Column = 1;
                app.LeftPanel.Layout.Row = 2;
                app.LeftPanel.Layout.Column = 1;
                app.RightPanel.Layout.Row = 3;
                app.RightPanel.Layout.Column = 1;
            elseif (currentFigureWidth > app.onePanelWidth && currentFigureWidth <= app.twoPanelWidth)
                % Change to a 2x2 grid
                app.GridLayout.RowHeight = {631, 631};
                app.GridLayout.ColumnWidth = {'1x', '1x'};
                app.CenterPanel.Layout.Row = 1;
                app.CenterPanel.Layout.Column = [1,2];
                app.LeftPanel.Layout.Row = 2;
                app.LeftPanel.Layout.Column = 1;
                app.RightPanel.Layout.Row = 2;
                app.RightPanel.Layout.Column = 2;
            else
                % Change to a 1x3 grid
                app.GridLayout.RowHeight = {'1x'};
                app.GridLayout.ColumnWidth = {335, '1x', 257};
                app.LeftPanel.Layout.Row = 1;
                app.LeftPanel.Layout.Column = 1;
                app.CenterPanel.Layout.Row = 1;
                app.CenterPanel.Layout.Column = 2;
                app.RightPanel.Layout.Row = 1;
                app.RightPanel.Layout.Column = 3;
            end
        end

        % Button pushed function: RemoveBCButton
        function removeBC(app, event)
            dummyOut = app.updateUndoStack;

            textBC = get(app.TextArea,'Value');
            eqnLoc = get(app.TextArea,'UserData'); % locations of headers
            idx = find(getappdata(app.PIETOOLSUIFigure,'EqnNum')==str2double(get(app.RemoveBCList,'Value'))); % find BC to remove
            
            textBC(idx) = []; % remove BC from list
            set(app.TextArea,'Value',textBC); % update List in app
            
        
            dummyOut = app.updateDisplay(textBC,eqnLoc);
%             dummyOut = app.updateRedoStack;
        end

        % Button pushed function: AddVar
        function addnewVar(app, event)
            dummyOut = app.updateUndoStack;
            
            % reset panels on the left
            dummyOut = app.resetLeftPanel;
            
            headerLoc = get(app.VarTable,'UserData');
            selectdata = headerLoc.SelectCell;
            headerLoc = headerLoc.headerLoc;
            
            allVars = get(app.VarTable,'Data');
            
            PDEvarlist = allVars(headerLoc(1,1)+1:headerLoc(2,1)-1,:);
            ODEvarlist = allVars(headerLoc(2,1)+1:headerLoc(3,1)-1,:);
            Disturbvarlist = allVars(headerLoc(3,1)+1:headerLoc(4,1)-1,:);
            Inputvarlist = allVars(headerLoc(4,1)+1:headerLoc(5,1)-1,:);
            RegOutvarlist = allVars(headerLoc(5,1)+1:headerLoc(6,1)-1,:);
            ObsOutvarlist = allVars(headerLoc(6,1)+1:end,:);
            
            if isempty(PDEvarlist)
                PDEvarlist = zeros([0,2]);
            end
            
            if strcmp(get(app.VarType, 'Value'),'PDE State')
                if ~isempty(PDEvarlist)
                    var_name = PDEvarlist{end,1};
                    var_name = ['X' num2str(str2double(var_name(2:end))+1)];
                else
                    var_name = 'X1';
                end
                allVars(headerLoc(2,1)+1:end+1,:) = allVars(headerLoc(2,1):end,:);
                allVars{headerLoc(2,1),1} = var_name;
                
                %get derivative value
                prompt = {'Enter max derivative of the new PDE state:'};
                dlgtitle = 'Input';
                answer = inputdlg(prompt,dlgtitle);
                
                
                try 
                    if isempty(answer)
                        answer=0;
                    else
                        answer = answer{1};
                        answer = str2double(answer);
                    end
                catch ME
                    errordlg('Max Derivative value must be a non-negative integer.');
                    answer=0;
                end
                if answer>10
                    errordlg("PIETOOLS only supports with PDEs with highest spatial derivative of 10.");
                    answer = 0;
                elseif answer<0
                    errordlg("Highest derivative value cannot be negative.");
                    answer = 0;
                elseif ~(mod(answer,1)==0)
                    answer = 0;
                    errordlg("Highest derivative value must be an integer.");
                end
                
                
                allVars{headerLoc(2,1),2} = answer;
                set(app.VarTable,'Data', allVars);
                
                headerLoc(2:end,1) = headerLoc(2:end,1) +1;
                datatmp = struct('headerLoc',headerLoc,'SelectCell',selectdata);
                set(app.VarTable,'UserData',datatmp);
                
                textDyn = get(app.TextArea,'Value');
                locs = get(app.TextArea,'UserData');
                textDyn(locs(2)+1:end+1) = textDyn(locs(2):end);
                textDyn{locs(2)} = ['$\partial_t ',var_name,' = 0$'];
                locs(2:end) = locs(2:end)+1;
                
                lastrowNum = max(getappdata(app.PIETOOLSUIFigure,'EqnNum'));
                
                for i=1:(answer)
                        textDyn{end+1} = ['$0 = 0$'];
                end
                
                set(app.TextArea,'Value',textDyn);
                set(app.TextArea,'UserData',locs);
                

            elseif strcmp(get(app.VarType, 'Value'),'ODE State')
                if ~isempty(ODEvarlist)
                    var_name = ODEvarlist{end,1};
                    var_name = ['x' num2str(str2double(var_name(2:end))+1)];
                else
                    var_name = 'x1';
                end
                allVars(headerLoc(3,1)+1:end+1,:) = allVars(headerLoc(3,1):end,:);
                allVars(headerLoc(3,1),1) = {var_name};
                set(app.VarTable,'Data', allVars);
                
                headerLoc(3:end,1) = headerLoc(3:end,1) +1;
                datatmp = struct('headerLoc',headerLoc,'SelectCell',selectdata);
                set(app.VarTable,'UserData',datatmp);
                
                textDyn = get(app.TextArea,'Value');
                locs = get(app.TextArea,'UserData');
                textDyn(locs(3)+1:end+1) = textDyn(locs(3):end);
                textDyn{locs(3)} = ['$\partial_t ',var_name,' = 0$'];
                locs(3:end) = locs(3:end)+1;
                set(app.TextArea,'Value',textDyn);
                set(app.TextArea,'UserData',locs);
                
            elseif strcmp(get(app.VarType, 'Value'),'Input')
                if ~isempty(Inputvarlist)
                    var_name = Inputvarlist{end,1};
                    var_name = ['u' num2str(str2double(var_name(2:end))+1)];
                else
                    var_name = 'u1';
                end
                allVars(headerLoc(5,1)+1:end+1,:) = allVars(headerLoc(5,1):end,:);
                allVars{headerLoc(5,1),1} = var_name;
                set(app.VarTable,'Data', allVars);
                
                headerLoc(5:end,1) = headerLoc(5:end,1) +1;
                datatmp = struct('headerLoc',headerLoc,'SelectCell',selectdata);
                set(app.VarTable,'UserData',datatmp);
                
            elseif strcmp(get(app.VarType, 'Value'),'Disturbance')
                if ~isempty(Disturbvarlist)
                    var_name = Disturbvarlist{end,1};
                    var_name = ['w' num2str(str2double(var_name(2:end))+1)];
                else
                    var_name = 'w1';
                end
                allVars(headerLoc(4,1)+1:end+1,:) = allVars(headerLoc(4,1):end,:);
                allVars{headerLoc(4,1),1} = var_name;
                set(app.VarTable,'Data', allVars);
                
                headerLoc(4:end,1) = headerLoc(4:end,1) +1;
                datatmp = struct('headerLoc',headerLoc,'SelectCell',selectdata);
                set(app.VarTable,'UserData',datatmp);
                
            elseif strcmp(get(app.VarType, 'Value'),'Regulated Output')
                if ~isempty(RegOutvarlist)
                    var_name = RegOutvarlist{end,1};
                    var_name = ['z' num2str(str2double(var_name(2:end))+1)];
                else
                    var_name = 'z1';
                end
                allVars(headerLoc(6,1)+1:end+1,:) = allVars(headerLoc(6,1):end,:);
                allVars{headerLoc(6,1),1} = var_name;
                set(app.VarTable,'Data', allVars);
                
                headerLoc(6:end,1) = headerLoc(6:end,1) +1;
                datatmp = struct('headerLoc',headerLoc,'SelectCell',selectdata);
                set(app.VarTable,'UserData',datatmp);
                
                textDyn = get(app.TextArea,'Value');
                locs = get(app.TextArea,'UserData');
                textDyn(locs(4)+1:end+1) = textDyn(locs(4):end);
                textDyn{locs(4)} = ['$', var_name,' = 0$'];
                locs(4:end) = locs(4:end)+1;
                set(app.TextArea,'Value',textDyn);
                set(app.TextArea,'UserData',locs);
                
            else 
                if ~isempty(ObsOutvarlist)
                    var_name = ObsOutvarlist{end,1};
                    var_name = ['y' num2str(str2double(var_name(2:end))+1)];
                else
                    var_name = 'y1';
                end
                allVars{end+1,1} = var_name;
                set(app.VarTable,'Data', allVars);
                
                datatmp = struct('headerLoc',headerLoc,'SelectCell',selectdata);
                set(app.VarTable,'UserData',datatmp);
                
                textDyn = get(app.TextArea,'Value');
                locs = get(app.TextArea,'UserData');
                textDyn(locs(5)+1:end+1) = textDyn(locs(5):end);
                textDyn{locs(5)} = ['$', var_name,' = 0$'];
                locs(5:end) = locs(5:end)+1;
                set(app.TextArea,'Value',textDyn);
                set(app.TextArea,'UserData',locs);
                
            end
            
            if exist('textDyn','var')
                dummyOut = app.updateDisplay(textDyn,locs);
            end
            
            removeStyle(app.VarTable);
            boldStyle = uistyle('FontWeight','bold');
            addStyle(app.VarTable,boldStyle,'cell',[headerLoc;[headerLoc(1,1) 2]]);
            
%             dummyOut = app.updateRedoStack;
        end

        % Button pushed function: RemoveButton
        function removeVar(app, event)
            dummyOut = app.updateUndoStack;
            
            % reset panels on the left
            dummyOut = app.resetLeftPanel;
             
            D=get(app.VarTable,'Data');
            Index=get(app.VarTable,'UserData');
            if ~isempty(Index.SelectCell)
                SelectedCell = Index.SelectCell; row2Remove = SelectedCell(1);
                headerlocs = Index.headerLoc; headerrows = headerlocs(:,1);
                if all(~ismember(row2Remove, headerrows))
                    % remove dynamics and output eqns
                    textDyn = get(app.TextArea,'Value');
                    locA = find(contains(textDyn,['$\partial_t ', D{row2Remove,1}, ' =']));
                    locB = find(contains(textDyn,['$', D{row2Remove,1}, ' =']));
                    locs = get(app.TextArea,'UserData');
                    
                    textDyn(locA) = [];
                    textDyn(locB) = [];
                    
                    if ~isempty(locA)
                        locs(locs>locA) = locs(locs>locA)-1;
                    elseif ~isempty(locB)
                        locs(locs>locB) = locs(locs>locB)-1;
                    end
                    
                    tmptextDyn = {};
                    for i=1:length(textDyn)
                        if contains(textDyn{i},D{row2Remove,1})
                            terms = split(textDyn{i});
                            for j=length(terms):-1:1
                                if contains(terms{j},D{row2Remove,1})
                                    terms(j) = [];
                                end
                            end
                            tmptext = terms{1};
                            for j=2:length(terms)
                                tmptext = strcat(tmptext, {' '}, terms{j});
                            end
                            tmptext=tmptext{1};
                            if strcmp(tmptext(end),'=')
                                tmptextDyn{i}=strcat(tmptext,' 0$');
                            elseif ~strcmp(tmptext(end),'$')
                                tmptextDyn{i}=strcat(tmptext,'$');
                            else
                                tmptextDyn{i}=tmptext;
                            end
                        else
                            tmptextDyn{i} = textDyn{i};
                        end
                    end
                    
                    set(app.TextArea,'UserData',locs);
                    set(app.TextArea,'Value',tmptextDyn);
                    
                    
                    dummyOut = app.updateDisplay(tmptextDyn,locs);

                    % remove from var list
                    D(row2Remove,:)=[];
                    set(app.VarTable,'Data',D);
                    headerlocs(headerrows>row2Remove) = headerlocs(headerrows>row2Remove)-1;
                    datatmp = struct('headerLoc',headerlocs,'SelectCell',SelectedCell);
                    set(app.VarTable,'UserData',datatmp);
                end
            end
            removeStyle(app.VarTable);
            boldStyle = uistyle('FontWeight','bold');
            addStyle(app.VarTable,boldStyle,'cell',[headerlocs;[headerlocs(1,1) 2]]);
            
%             dummyOut = app.updateRedoStack;
        end

        % Cell selection callback: VarTable
        function varSelectCallback(app, event)
            indices = event.Indices;
            tmpstruct = get(app.VarTable,'UserData');
            tmpstruct.SelectCell = indices;
            set(app.VarTable,'UserData',tmpstruct);
        end

        % Value changed function: TermType
        function termTypeChange(app, event)
            selectedButton = app.ButtonGroup.SelectedObject;
            buttonName = get(selectedButton,'Text');
            if strcmp(buttonName, 'None')
                tmp = errordlg("Select an equation type and an equation before selecting term type");
                set(app.TermType,'Value', ' ');
                return
            end
            if (strcmp(get(app.LHSDropDown_Dyn,'Value'),' ')&&strcmp(buttonName,'Dynamics'))||...
                    (strcmp(get(app.LHSDropDown_output,'Value'),' ')&&strcmp(buttonName,'Output'))
                tmp = errordlg("Select an equation before selecting term type");
                set(app.TermType,'Value', ' ');
                return
            end
            
            
            set(app.d_sLabel,'Visible','off');
            set(app.derivativeOrder,'Visible','off');
            set(app.IndepVar,'Visible','off');
            set(app.Label,'Visible','off');
            set(app.Label_2,'Visible','off');
            
            % reset panels on the left
            set(app.derivativeOrder,'Value',0);
            set(app.ProductList,'Value', ' ');
            set(app.Coefficient,'Value','1');
            
            value = app.TermType.Value;
            rowNums = getappdata(app.PIETOOLSUIFigure,'EqnNum');
            tmpidx = find(rowNums==0);
            
            if strcmp(value,'Standard')
                set(app.Label_3, 'Visible', 'on');
                set(app.Coefficient,'Visible','on');
                set(app.ProductList,'Visible','on');
                set(app.intLabel,'Visible','off');
                set(app.intLowerLimit,'Visible','off');
                set(app.intUpperLimit,'Visible','off');
                set(app.IntVariable,'Visible','off');
                
                List = getVarList(app.VarTable,'allRHS');
                set(app.ProductList,'Items',[' '; List(:,1)]);
                
                selectedButton = app.ButtonGroup.SelectedObject;
                buttonName = get(selectedButton,'Text');
                
                set(app.ProductList,'Value', ' ');
                if strcmp(buttonName,' ')
                    tmp = errordlg("Select an equation before adding terms");
                elseif ~strcmp(buttonName,'Dynamics')                    
                    set(app.IndepVar,'Items',{'0';'1'});
                elseif ismember(str2double(get(app.LHSDropDown_Dyn,'Value')),rowNums(tmpidx(1):tmpidx(2)))%contains(get(app.LHSDropDown_Dyn,'Value'),'X')
                    set(app.IndepVar,'Items',{'s';'0';'1'});
                elseif ismember(str2double(get(app.LHSDropDown_Dyn,'Value')),rowNums(tmpidx(2):tmpidx(3)))%contains(get(app.LHSDropDown_Dyn,'Value'),'x')
                    set(app.IndepVar,'Items',{'0';'1'});
                end
            elseif strcmp(value,'Integral')
                set(app.Label_3, 'Visible', 'on');
                set(app.Coefficient,'Visible','on');
                set(app.ProductList,'Visible','on');
                set(app.intLabel,'Visible','on');
                set(app.intLowerLimit,'Visible','on');
                set(app.intUpperLimit,'Visible','on');
                set(app.IntVariable,'Visible','on');
                set(app.IndepVar,'Visible','on');
                set(app.Label,'Visible','on');
                set(app.Label_2,'Visible','on');
                
                List = getVarList(app.VarTable,'pde');
                set(app.ProductList,'Items',[' '; List(:,1)]);
                
                selectedButton = app.ButtonGroup.SelectedObject;
                buttonName = get(selectedButton,'Text');
                
                set(app.ProductList,'Value', ' ');
                if strcmp(buttonName,' ')
                    tmp = errordlg("Select an equation before adding terms");
                elseif ~strcmp(buttonName,'Dynamics')                    
                    set(app.IndepVar,'Items',{'s'});
                    set(app.IntVariable,'Items',{'ds'});
                    set(app.intLowerLimit,'Items',{'0'});
                    set(app.intUpperLimit,'Items',{'1'});
                elseif ismember(str2double(get(app.LHSDropDown_Dyn,'Value')),rowNums(tmpidx(1):tmpidx(2)))%contains(get(app.LHSDropDown_Dyn,'Value'),'X')
                    set(app.IndepVar,'Items',{char(0x03B8);});
                    set(app.IntVariable,'Items',{['d',char(0x03B8)]});
                    set(app.intLowerLimit,'Items',{'0';'s'});
                    set(app.intUpperLimit,'Items',{'s';'1'});
                elseif ismember(str2double(get(app.LHSDropDown_Dyn,'Value')),rowNums(tmpidx(2):tmpidx(3)))%contains(get(app.LHSDropDown_Dyn,'Value'),'x')
                    set(app.IndepVar,'Items',{'s'});
                    set(app.IntVariable,'Items',{'ds'});
                    set(app.intLowerLimit,'Items',{'0'});
                    set(app.intUpperLimit,'Items',{'1'});
                end
            end
        end

        % Value changed function: ProductList
        function stateTermTypeChange(app, event)
            value = app.ProductList.Value;
            
            if strcmp(value(1),'X')
                set(app.d_sLabel,'Visible','on');
                set(app.derivativeOrder,'Visible','on');
                set(app.IndepVar,'Visible','on');
                set(app.Label,'Visible','on');
                set(app.Label_2,'Visible','on');
            else
                set(app.d_sLabel,'Visible','off');
                set(app.derivativeOrder,'Visible','off');
                set(app.IndepVar,'Visible','off');
                set(app.Label,'Visible','off');
                set(app.Label_2,'Visible','off');
            end
        end

        % Cell edit callback: VarTable
        function changeDerivative(app, event)
            previousStates = get(app.UndoButton,'UserData');
            previousStates(1:end-1) = previousStates(2:end); %erase furthest history
            
            indices = event.Indices;
            newData = event.NewData;
            previousData = event.PreviousData;
            
            tmp.vars = get(app.VarTable,'Data');
            tmp.varheaders = get(app.VarTable,'UserData');
            tmp.eqns = get(app.TextArea, 'Value');
            tmp.eqnheaders = get(app.TextArea, 'UserData');
            
            tmp.vars{indices(1),indices(2)} = previousData;
            
            previousStates{end} = tmp; % store current state
            set(app.UndoButton,'UserData',previousStates);
            
            
            headerLoc = get(app.VarTable,'UserData');
            selectdata = headerLoc.SelectCell;
            headerLoc = headerLoc.headerLoc;
            
            allVars = get(app.VarTable,'Data');
            
            if indices(1)>headerLoc(1,1) && indices(1)<headerLoc(2,1)
                if newData>10
                    allVars{indices(1),indices(2)} = previousData;
                    set(app.VarTable,'Data',allVars);
                    errordlg("PIETOOLS only supports with PDEs with highest spatial derivative of 10.");
                    return
                elseif newData<0
                    allVars{indices(1),indices(2)} = previousData;
                    set(app.VarTable,'Data',allVars);
                    errordlg("Highest derivative value cannot be negative.");
                    return
                else
                    allVars{indices(1),indices(2)} = newData;
                end
                if newData>previousData
                    textBC = get(app.TextArea,'Value');
                    BClist = get(app.LHSDropDown_BC,'Items');
                    for i=1:(newData-previousData)
                        textBC{end+1} = ['$0 = 0$'];
                        BClist{end+1} = num2str(length(BClist)+1);
                    end
                    set(app.LHSDropDown_BC,'Items',BClist);
                    set(app.RemoveBCList,'Items',BClist);
                    set(app.TextArea,'Value',textBC);
                    
                
                    dummyOut = app.updateDisplay(textBC,tmp.eqnheaders);
            
%                     textBC=erase(textBC,'*');
%                     cla(app.Eqns);
%                     text(app.Eqns,0,1,textBC,'VerticalAlignment','top','interpreter','latex');
                end
            else
                allVars{indices(1),indices(2)} = event.PreviousData;
            end
            set(app.VarTable,'Data',allVars);
            
%             dummyOut = app.updateRedoStack;
        end

        % Button pushed function: UndoButton
        function undoPress(app, event)
            previousStates = get(app.UndoButton,'UserData');
            futureStates = get(app.RedoButton,'UserData');
            
            tmp.vars = get(app.VarTable,'Data');
            tmp.varheaders = get(app.VarTable,'UserData');
            tmp.eqns = get(app.TextArea, 'Value');
            tmp.eqnheaders = get(app.TextArea, 'UserData');
            tmp.EqnNum = getappdata(app.PIETOOLSUIFigure,'EqnNum');
            
            %push current state into future state for ReDo option
            futureStates(2:end) = futureStates(1:end-1); % erase furthestmost future
            futureStates{1} = tmp;
            
            %pull current state from previous state to perform undo
            tmp2 = previousStates{end};
            previousStates(2:end) = previousStates(1:end-1);%erase furthest history
            
            set(app.VarTable, 'Data', tmp2.vars);
            set(app.VarTable, 'UserData', tmp2.varheaders);
            
            set(app.TextArea, 'Value', tmp2.eqns);
            set(app.TextArea, 'UserData', tmp2.eqnheaders);
            
            set(app.ButtonGroup.Buttons(1,4),'Value',1);
            set(app.d_sLabel,'Visible','off');
            set(app.derivativeOrder,'Visible','off');
            set(app.IndepVar,'Visible','off');
            set(app.Label,'Visible','off');
            set(app.Label_2,'Visible','off');
            set(app.TermType, 'Value', ' ');
            set(app.ProductList, 'Value', ' ');
            
            set(app.UndoButton,'UserData',previousStates);
            set(app.RedoButton,'UserData',futureStates);
            
            removeStyle(app.VarTable);
            boldStyle = uistyle('FontWeight','bold');
            addStyle(app.VarTable,boldStyle,'cell',[tmp2.varheaders.headerLoc;[tmp2.varheaders.headerLoc(1,1) 2]]);
            
            dummyOut = app.updateDisplay(tmp2.eqns,tmp2.eqnheaders);
        end

        % Selection changed function: ButtonGroup
        function selectEquation2Add(app, event)
            selectedButton = app.ButtonGroup.SelectedObject;
            buttonName = get(selectedButton,'Text');
            
            if strcmp(buttonName,'Dynamics')
                PDEvars = getVarList(app.VarTable,'pde');
                ODEvars = getVarList(app.VarTable,'ode');
                list = [PDEvars;ODEvars];
                set(app.LHSDropDown_Dyn,'Items',[' ';list(:,1)]);
                set(app.LHSDropDown_Dyn,'Value',' ');
                set(app.LHSDropDown_Dyn,'Visible', 'on');
                set(app.LHSDropDown_output,'Visible', 'off');
                set(app.LHSDropDown_BC,'Visible', 'off');
            elseif strcmp(buttonName,'Output')
                Outvars = getVarList(app.VarTable,'output');
                set(app.LHSDropDown_output,'Items',[' '; Outvars(:,1)]);
                set(app.LHSDropDown_output,'Value',' ');
                set(app.LHSDropDown_Dyn,'Visible', 'off');
                set(app.LHSDropDown_output,'Visible', 'on');
                set(app.LHSDropDown_BC,'Visible', 'off');
            elseif strcmp(buttonName,'BC')
                set(app.LHSDropDown_Dyn, 'Visible', 'off');
                set(app.LHSDropDown_output, 'Visible', 'off');
                set(app.LHSDropDown_BC, 'Visible', 'on');
            end
            
            % reset panels on the left
            set(app.TermType,'Value',' ');
            set(app.Coefficient,'Visible','off');
            set(app.ProductList,'Visible','off');
            set(app.intLabel,'Visible','off');
            set(app.intLowerLimit,'Visible','off');
            set(app.intUpperLimit,'Visible','off');
            set(app.IntVariable,'Visible','off');
            set(app.d_sLabel,'Visible','off');
            set(app.derivativeOrder,'Visible','off');
            set(app.derivativeOrder,'Value',0);
            set(app.ProductList,'Value', ' ');
            set(app.IndepVar,'Visible','off');
            set(app.Label, 'Visible','off');
            set(app.Label_2, 'Visible','off');
            set(app.Label_3, 'Visible', 'off');
            set(app.Coefficient,'Value','1');
        end

        % Button pushed function: AddButton
        function addTerm2Equation(app, event)
            dummyOut = app.updateUndoStack;
             
            % fetch information about the term to be added
            termType = get(app.TermType,'Value'); %multiplier or integral
            coeff = get(app.Coefficient,'Value'); %polynomial coeff
            stateterm = get(app.ProductList,'Value'); %x, X, w or u
            stateArg = get(app.IndepVar, 'Value'); %(s), (theta), (0) or (1)
            a = get(app.intLowerLimit,'Value'); % (0) or (s)
            b = get(app.intUpperLimit, 'Value'); % (s) or (1)
            intvar = get(app.IntVariable, 'Value'); % (ds) or (dtheta)
            derOrder = get(app.derivativeOrder,'Value'); % get order of derivative
            
            % change unicode to text
            if strcmp(stateArg,char(0x03B8))
                stateArg = '\theta';
            end
            if strcmp(intvar, ['d',char(0x03B8)])
                intvar = 'd\theta';
            end
            
            % find which equation to add the term to
            whichEqn = app.ButtonGroup.SelectedObject;
            whichEqn = get(whichEqn,'Text'); % dynamics, output or BC
            
            % get all equations
            textDyn = get(app.TextArea,'Value');
            eqnLoc = get(app.TextArea,'UserData'); % locations of headers
                
            % extract the equation from the list of equations
            if strcmp(whichEqn, 'Dynamics')
                LHS = get(app.LHSDropDown_Dyn,'Value');
                rowNums = getappdata(app.PIETOOLSUIFigure,'EqnNum');
                idx = find(rowNums==0);
                DynEqnNums = rowNums(idx(2):idx(3));
                DynEqnNums = DynEqnNums(DynEqnNums~=0);
                if ismember(str2double(LHS),DynEqnNums) %contains(LHS,'x')
                    eqntype='finite';
                else
                    eqntype='infinite';
                end
                idx = find(rowNums==str2double(LHS)); % find line number of equation
            elseif strcmp(whichEqn, 'Output')
                LHS = get(app.LHSDropDown_output,'Value');
                rowNums = getappdata(app.PIETOOLSUIFigure,'EqnNum');
                eqntype='finite';
                idx = find(rowNums==str2double(LHS)); % find line number of equation
            elseif strcmp(whichEqn, 'BC')
                LHS = get(app.LHSDropDown_BC,'Value');
                eqntype='finite';
                rowNums = getappdata(app.PIETOOLSUIFigure,'EqnNum');
                idx = find(rowNums==str2double(LHS));% find line number of 
            else
                errordlg('Select an equation in step 2 before adding term in step 2a.');
                return
            end
            
            % if idx is empty then no equation is selected
            if isempty(idx)
                errordlg('Select an equation in step 2 before adding term in step 2a.');
                return
            end
            
            %split variables into categories for convenience
            PDEvarlist = getVarList(app.VarTable,'pde');
            
            % test if coefficient entered is a valid polynomial function
            logicalval = isvalidPolynomial(coeff);
            
            % test if coefficient is a number, polynomial in s or theta
            if ~contains(coeff, 'theta')&& ~contains(coeff, 's')
                coeffIsNum = 0;
            elseif ~contains(coeff, 'theta')
                coeffIsNum = 1;
            elseif ~contains(coeff, 's')
                coeffIsNum = 2;
            else
                coeffIsNum = 3;
            end
            
            
            % replace all thetas with \theta for Latex display
            coeff = replace(coeff,'theta','\theta');
            coeff = regexprep(coeff,'\s',''); %remove whitespaces
            if logicalval==0 % everything fine, add term
                existingTxt = textDyn{idx}; % extract line
                
                % remove 0 and $ for Latex formatting
                if strcmp(existingTxt(end-3:end),'= 0$')
                    existingTxt=existingTxt(1:end-2);
                else
                    existingTxt=existingTxt(1:end-1);
                end
                
                if strcmp(termType,' ')
                    errordlg("Select Termtype before adding the term.");
                elseif strcmp(termType, 'Standard')
                    if strcmp(eqntype,'finite')&&coeffIsNum~=0
                        errordlg("Cannot add a term whose coefficient has polynomial variables while being added to a finite dimensional equation.");
                        return
                    end
                    if strcmp(eqntype,'infinite')&&coeffIsNum>=2
                        errordlg("Cannot add a term whose coefficient has theta while being added to PDE.");
                        return
                    end
                    
                    if strcmp(get(app.ProductList,'Value'),' ')
                        errordlg("Select state term that multiplies the coefficient to add the term.");
                    elseif contains(get(app.ProductList,'Value'),'X')
                        idx2 = find(strcmp(PDEvarlist(:,1),stateterm));
                        thirdPart = [stateterm,'(',stateArg,')$'];
                    else
                        idx2 = [];
                        thirdPart = [stateterm,'$'];
                    end
                    
                    if ~isempty(idx2) % term being added is a PDE state
                        highestDer = PDEvarlist{idx2,2};
                        if derOrder<0
                            errordlg("Derivative order cannot be negative.");
                            return
                        elseif (strcmp(stateArg,'s'))&&(derOrder>highestDer(1))
                            errordlg("Derivative order is higher than max derivative of PDE state.");
                            return
                        elseif (strcmp(stateArg,'0')||strcmp(stateArg,'1'))&&...
                                (derOrder>=highestDer(1))
                            errordlg("Specified term is not continuous and hence boundary value term cannot be added.");
                            return
                        end
                    end
                        
                    if strcmp(existingTxt(end-1:end),'= ')
                        if strcmp(coeff(1),'-')&&~contains(coeff(2:end),'+')&&~contains(coeff(2:end),'-')
                            % do nothing single terms with minus sign at
                            % the beginning
                        elseif strcmp(coeff(1),'+')&&~contains(coeff(2:end),'+')&&~contains(coeff(2:end),'-')
                            % single term, remove unnecessary plus sign at
                            % the beginning
                            coeff = coeff(2:end);
                        elseif ~contains(coeff,'+')&&~contains(coeff,'-')
                            % single term, no sign at
                            % the beginning, do nothing
                            if strcmp(coeff,'1')
                                coeff = '';
                            end
                        else
                            % multiple terms, brackets needed
                            coeff = ['(',coeff,')'];
                        end
                    else
                        if strcmp(coeff(1),'-')&&~contains(coeff(2:end),'+')&&~contains(coeff(2:end),'-')
                            % do nothing single terms with minus sign at
                            % the beginning
                        elseif strcmp(coeff(1),'+')&&~contains(coeff(2:end),'+')&&~contains(coeff(2:end),'-')
                            % do nothing single terms with plus sign at
                            % the beginning
                        elseif ~contains(coeff,'+')&&~contains(coeff,'-')
                            % single term with no sign
                            if strcmp(coeff,'1')
                                coeff = '';
                            end
                            coeff = ['+',coeff];
                        else
                            % multiple terms, brackets needed
                            coeff = ['+(',coeff,')'];
                        end
                    end
                    firstPart = [existingTxt,' ',coeff,'*'];
                    if derOrder==0 || ~contains(get(app.ProductList,'Value'),'X')
                        secondPart = '';
                    elseif derOrder==1
                        secondPart = '\partial_s';
                    else
                        secondPart = strcat('\partial_s^',num2str(derOrder));
                    end
                    replaceTxt = strcat(firstPart,secondPart,thirdPart);
                    textDyn{idx} = replaceTxt;
                else % integral term
                    if strcmp(eqntype,'finite')&&coeffIsNum>=2
                        errordlg("Cannot add an integral term whose integrand has theta while being added to a finite dimensional equation.");
                        return
                    end
                    if strcmp(a,b)
                        errordlg("Limits of integration cannot be equal.");
                        return
                    end
                    idx2 = find(strcmp(PDEvarlist(:,1),stateterm));
                    if ~isempty(idx2) % term being added is a PDE state
                        highestDer = PDEvarlist{idx2,2};
                        if derOrder<0
                            errordlg("Derivative order cannot be negative.");
                            return
                        elseif (strcmp(stateArg,'s')||strcmp(stateArg,'\theta'))&&(derOrder>highestDer(1))
                            errordlg("Derivative order is higher than max derivative of PDE state.");
                            return
                        end
                    end
                    if strcmp(existingTxt(end-1:end),'= ')
                        if strcmp(coeff(1),'-')&&~contains(coeff(2:end),'+')&&~contains(coeff(2:end),'-')
                            % single term with minus sign at
                            % the beginning
                            firstPart = [existingTxt,' ','-\int_',a,'^',b,coeff(2:end),'*'];
                        elseif strcmp(coeff(1),'+')&&~contains(coeff(2:end),'+')&&~contains(coeff(2:end),'-')
                            % single term, remove unnecessary plus sign at
                            % the beginning
                            firstPart = [existingTxt,' ','\int_',a,'^',b,coeff(2:end),'*'];
                        elseif ~contains(coeff,'+')&&~contains(coeff,'-')
                            % single term, no sign at
                            % the beginning
                            if strcmp(coeff,'1')
                                coeff = '';
                            end
                            firstPart = [existingTxt,' ','\int_',a,'^',b,coeff,'*'];
                        else
                            % multiple terms, brackets needed
                            firstPart = [existingTxt,' ','\int_',a,'^',b,'(',coeff,')*'];
                        end
                        
                    else
                        if strcmp(coeff(1),'-')&&~contains(coeff(2:end),'+')&&~contains(coeff(2:end),'-')
                            % single terms with minus sign at
                            % the beginning
                            firstPart = [existingTxt,' ','-\int_',a,'^',b,coeff(2:end),'*'];
                        elseif strcmp(coeff(1),'+')&&~contains(coeff(2:end),'+')&&~contains(coeff(2:end),'-')
                            % single terms with plus sign at
                            % the beginning
                            firstPart = [existingTxt,' ','+\int_',a,'^',b,coeff(2:end),'*'];
                        elseif ~contains(coeff,'+')&&~contains(coeff,'-')
                            % single terms with no sign at
                            % the beginning
                            if strcmp(coeff,'1')
                                coeff = '';
                            end
                            firstPart = [existingTxt,' ','+\int_',a,'^',b,coeff,'*'];
                        else
                            % multiple terms, brackets needed
                            coeff = ['(',coeff,')'];
                            firstPart = [existingTxt,' ','+\int_',a,'^',b,coeff,'*'];
                        end
                    end
                    if derOrder==0
                        secondPart = '';
                    elseif derOrder==1
                        secondPart = '\partial_s';
                    else
                        secondPart = strcat('\partial_s^',num2str(derOrder));
                    end
                    replaceTxt = [firstPart,secondPart,stateterm,'(',stateArg,')',intvar,'$'];
                    textDyn{idx} = replaceTxt;
                end
            elseif logicalval~= 0 % input coeff is not a valid matlab polynomial
                if logicalval==2
                    errordlg('Coefficient has unidentified polynomial variable different from s or theta');
                end
                if logicalval==3
                    errordlg('Coefficient has polynomial variable with exponent that is either negative or non-integer');
                end
                if logicalval==4
                    errordlg('Coefficient is not a valid MATLAB expression. Check for mismatched brackets, incorrect operands, etc.');
                end
                return
            end
            set(app.TextArea,'Value',textDyn);
            
        
            dummyOut = app.updateDisplay(textDyn,eqnLoc);
            
%             dummyOut = app.updateRedoStack;
        end

        % Menu selected function: helpAddNewBC
        function helpNewBC(app, event)
            tmp = msgbox('This button adds a new boundary condition to the list of boundary conditions.','Component Description','modal');
        end

        % Button pushed function: RedoButton
        function redoPress(app, event)
            previousStates = get(app.UndoButton,'UserData');
            futureStates = get(app.RedoButton,'UserData');
            
            tmp.vars = get(app.VarTable,'Data');
            tmp.varheaders = get(app.VarTable,'UserData');
            tmp.eqns = get(app.TextArea, 'Value');
            tmp.eqnheaders = get(app.TextArea, 'UserData');
            tmp.EqnNum = getappdata(app.PIETOOLSUIFigure,'EqnNum');
            
            %pull future state  for ReDo option
            tmp2 = futureStates{1};
            
            % if redo is empty do nothing
            if isempty(tmp2)
                return
            end
            
            futureStates(1:end-1) = futureStates(2:end); % erase furthestmost future
            futureStates{end} = {};
            
            %push current state from previous state to perform undo            
            previousStates(1:end-1) = previousStates(2:end); %erase furthest history
            previousStates{end} = tmp;
            
            set(app.VarTable, 'Data', tmp2.vars);
            set(app.VarTable, 'UserData', tmp2.varheaders);
            
            set(app.TextArea, 'Value', tmp2.eqns);
            set(app.TextArea, 'UserData', tmp2.eqnheaders);
            
            set(app.ButtonGroup.Buttons(1,4),'Value',1);
            set(app.d_sLabel,'Visible','off');
            set(app.derivativeOrder,'Visible','off');
            set(app.IndepVar,'Visible','off');
            set(app.Label,'Visible','off');
            set(app.Label_2,'Visible','off');
            set(app.TermType, 'Value', ' ');
            set(app.ProductList, 'Value', ' ');
            
            set(app.UndoButton,'UserData',previousStates);
            set(app.RedoButton,'UserData',futureStates);
            
            removeStyle(app.VarTable);
            boldStyle = uistyle('FontWeight','bold');
            addStyle(app.VarTable,boldStyle,'cell',[tmp2.varheaders.headerLoc;[tmp2.varheaders.headerLoc(1,1) 2]]);
            
            
            dummyOut = app.updateDisplay(tmp2.eqns,tmp2.eqnheaders);
        end

        % Button pushed function: GetPDEObjectButton
        function getPDEparams(app, event)
            set(app.StatusBox,'Text','Parsing PDE to obtain PDE object...');
            varTable = getVarList(app.VarTable,'all');
            Text = get(app.TextArea,'Value');
            TextLoc = get(app.TextArea, 'UserData');
            if isempty(varTable)%length(varTable)==0
                errordlg('Equations and states are not defined. PIETOOLS cannot parse convert a system zero states and equations.')
                return 
            end
            
            rowNums = getappdata(app.PIETOOLSUIFigure,'EqnNum');
            idx = find(rowNums==0);
            DynEqnNums = rowNums(idx(5)+1:end);
            numberBC = length(DynEqnNums);
            
            PDEtab = getVarList(app.VarTable,'pde');
            derList = PDEtab(:,2);
            totalAllowedBC = 0;
            for i=1:length(derList)
                totalAllowedBC = totalAllowedBC+ derList{i};
            end
            
            if numberBC<totalAllowedBC
                errordlg('Support for insufficient number of BCs will be added in later version of PIETOOLS. Currently, the number of BC must be equal to sum of max derivatives of PDE states.');
                return
            elseif numberBC>totalAllowedBC
                errordlg('Number of BCs exceed number of required BCs. Remove unnecessary boundary conditions or check highest derivatives of PDE states.');
                return
            end
            PDE=parsePDEParams(varTable,Text,TextLoc);
            assignin('base','PDE_GUI',PDE);
            
            set(app.StatusBox,'Text','PDE object saved to workspace as PDE_GUI.');
        end

        % Button pushed function: SaveButton
        function saveState(app, event)
            data.vars = get(app.VarTable,'Data');
            data.varheaders = get(app.VarTable,'UserData');
            data.eqns = get(app.TextArea,'Value');
            data.eqnheaders = get(app.TextArea,'UserData');
            [file,path] = uiputfile('*.mat');
            if file==0
                return
            end
            save([path,file],'data','-mat');
            set(app.StatusBox,'Text', 'Saved PDE object as .mat file');
        end

        % Button pushed function: LoadButton
        function loadState(app, event)
            %reset panels on the left
            set(app.ButtonGroup.Buttons(1,4),'Value',1);
%             set(app.LHSDropDown_Dyn,'Value',' ');
%             set(app.LHSDropDown_output,'Value',' ');
            set(app.LHSDropDown_Dyn,'Visible', 'off');
            set(app.LHSDropDown_output,'Visible', 'off');
            set(app.LHSDropDown_BC,'Visible', 'off');
            set(app.TermType,'Value',' ');
            set(app.Coefficient,'Visible','off');
            set(app.ProductList,'Visible','off');
            set(app.intLabel,'Visible','off');
            set(app.intLowerLimit,'Visible','off');
            set(app.intUpperLimit,'Visible','off');
            set(app.IntVariable,'Visible','off');
            set(app.d_sLabel,'Visible','off');
            set(app.derivativeOrder,'Visible','off');
            set(app.derivativeOrder,'Value',0);
            set(app.ProductList,'Value', ' ');
            set(app.IndepVar,'Visible','off');
            set(app.Label, 'Visible','off');
            set(app.Label_2, 'Visible','off');
            set(app.Label_3, 'Visible', 'off');
            set(app.Coefficient,'Value','1');
            
            
            [name, path] = uigetfile('*.mat');
            if name==0
                set(app.StatusBox,'Text', 'No file selected. PDE object could not be loaded.');
                return
            end
            opened = load([path,name]);
            data = opened.data;
            set(app.VarTable,'Data',data.vars);
            set(app.VarTable,'UserData',data.varheaders);
            set(app.TextArea,'Value',data.eqns);
            set(app.TextArea,'UserData',data.eqnheaders);
            figure(app.PIETOOLSUIFigure);
           
            
            removeStyle(app.VarTable);
            boldStyle = uistyle('FontWeight','bold');
            addStyle(app.VarTable,boldStyle,'cell',[data.varheaders.headerLoc;[data.varheaders.headerLoc(1,1) 2]]);
            
        
            dummyOut = app.updateDisplay(data.eqns,data.eqnheaders);
    
            set(app.StatusBox,'Text', 'PDE object has be successfully loaded.');
        end

        % Value changed function: LHSDropDown_Dyn
        function dynamicsEqnSelect(app, event)
            value = app.LHSDropDown_Dyn.Value;
            
            % reset panels on the left
            set(app.TermType,'Value',' ');
            set(app.intLabel,'Visible','off');
            set(app.intLowerLimit,'Visible','off');
            set(app.intUpperLimit,'Visible','off');
            set(app.IntVariable,'Visible','off');
            set(app.d_sLabel,'Visible','off');
            set(app.derivativeOrder,'Visible','off');
            set(app.derivativeOrder,'Value',0);
            set(app.ProductList,'Value', ' ');
            set(app.IndepVar,'Visible','off');
            set(app.Label, 'Visible','off');
            set(app.Label_2, 'Visible','off');
            set(app.Coefficient,'Value','1');
        end

        % Button pushed function: AddnewBCButton
        function addNewBC(app, event)
            dummyOut = app.updateUndoStack;
            
            textBC = get(app.TextArea,'Value');
            
            rowNums = getappdata(app.PIETOOLSUIFigure,'EqnNum');
            idx = find(rowNums==0);
            DynEqnNums = rowNums(idx(5)+1:end);
            
            numberBC = length(DynEqnNums);
            
            PDEtab = getVarList(app.VarTable,'pde');
            derList = PDEtab(:,2);
            totalAllowedBC = 0;
            for i=1:length(derList)
                totalAllowedBC = totalAllowedBC+ derList{i};
            end
            
            
            if numberBC>=totalAllowedBC
                errordlg('Number of BCs cannot be higher than sum of max derivatives of PDE states.');
                return
            else
                textBC{end+1} = ['$0 = 0$'];
                set(app.TextArea,'Value',textBC);
            end
            
            dummyOut = app.updateDisplay(textBC,get(app.TextArea,'UserData'));
            

        end

        % Button pushed function: ConverttoPIEButton
        function convert2PIE(app, event)
            set(app.StatusBox,'Text','Parsing PDE to obtain PDE object...');
            varTable = getVarList(app.VarTable,'all');
            Text = get(app.TextArea,'Value');
            TextLoc = get(app.TextArea, 'UserData');
            if isempty(varTable)%length(varTable)==0
                errordlg('Equations and states are not defined. PIETOOLS cannot parse convert a system zero states and equations.')
                return 
            end
            
            rowNums = getappdata(app.PIETOOLSUIFigure,'EqnNum');
            idx = find(rowNums==0);
            DynEqnNums = rowNums(idx(5)+1:end);
            numberBC = length(DynEqnNums);
            
            PDEtab = getVarList(app.VarTable,'pde');
            derList = PDEtab(:,2);
            totalAllowedBC = 0;
            for i=1:length(derList)
                totalAllowedBC = totalAllowedBC+ derList{i};
            end
            
            if numberBC<totalAllowedBC
                errordlg('Support for insufficient number of BCs will be added in later version of PIETOOLS. Currently, the number of BC must be equal to sum of max derivatives of PDE states.');
                return
            elseif numberBC>totalAllowedBC
                errordlg('Number of BCs exceed number of required BCs. Remove unnecessary boundary conditions or check highest derivatives of PDE states.');
                return
            end
            PDE=parsePDEParams(varTable,Text,TextLoc);
            
            set(app.StatusBox,'Text','Converting PDE object to PIE object...');
            PIE = convert_PIETOOLS_PDE_terms(PDE);
            
            if strcmp(PIE,'Cannot convert to PIE')
                errordlg('Currently PIE conversion is supported only for PDEs with atleast one BC');
            elseif strcmp(PIE,'Singular ET')
                errordlg('Defined boundary conditions are rank deficient or have prohibited boundary conditions. Your system is likely ill-posed.');
            end
            assignin('base','PIE_GUI',PIE);
            
            set(app.StatusBox,'Text','PIE object saved to workspace as PIE_GUI.');
        end

        % Drop down opening function: LHSDropDown_Dyn
        function dynamicsDropOpen(app, event)
            rowNums = getappdata(app.PIETOOLSUIFigure,'EqnNum');
            idx = find(rowNums==0);
            DynEqnNums = rowNums(idx(1):idx(3));
            DynEqnNums = DynEqnNums(DynEqnNums~=0);
            set(app.LHSDropDown_Dyn,'Items',cellfun(@num2str,num2cell(DynEqnNums),'UniformOutput',false));
        end

        % Drop down opening function: LHSDropDown_output
        function OutputDropOpen(app, event)
            rowNums = getappdata(app.PIETOOLSUIFigure,'EqnNum');
            idx = find(rowNums==0);
            DynEqnNums = rowNums(idx(3):idx(5));
            DynEqnNums = DynEqnNums(DynEqnNums~=0);
            set(app.LHSDropDown_output,'Items',cellfun(@num2str,num2cell(DynEqnNums),'UniformOutput',false));
        end

        % Drop down opening function: LHSDropDown_BC
        function BCDropOpen(app, event)
            rowNums = getappdata(app.PIETOOLSUIFigure,'EqnNum');
            idx = find(rowNums==0);
            DynEqnNums = rowNums(idx(5)+1:end);
            set(app.LHSDropDown_BC,'Items',cellfun(@num2str,num2cell(DynEqnNums),'UniformOutput',false));
        end

        % Drop down opening function: RemoveBCList
        function RemoveBCDropOpen(app, event)
            rowNums = getappdata(app.PIETOOLSUIFigure,'EqnNum');
%             rowNums = get(app.Label,'UserData');
            idx = find(rowNums==0);
            DynEqnNums = rowNums(idx(5)+1:end);
            set(app.RemoveBCList,'Items',cellfun(@num2str,num2cell(DynEqnNums),'UniformOutput',false));
        end
    end

    % Component initialization
    methods (Access = private)

        % Create UIFigure and components
        function createComponents(app)
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            app.PIETOOLSUIFigure = uifigure('Visible', 'off');
            app.PIETOOLSUIFigure.Name = 'PIETOOLS';
            app.PIETOOLSUIFigure.SizeChangedFcn = createCallbackFcn(app, @updateAppLayout, true);
            app.GridLayout = uigridlayout(app.PIETOOLSUIFigure);
            app.LeftPanel = uipanel(app.GridLayout);
            app.SelectanequationtypeandthenselecttheequationPanel = uipanel(app.LeftPanel);
            app.SelectanequationtypeandthenselecttheequationPanel.Title = 'Select an equation type and then select the equation -';
            app.LHSDropDown_Dyn = uidropdown(app.SelectanequationtypeandthenselecttheequationPanel);
            app.LHSDropDown_Dyn.Items = {};
            app.LHSDropDown_Dyn.DropDownOpeningFcn = createCallbackFcn(app, @dynamicsDropOpen, true);
            app.LHSDropDown_Dyn.ValueChangedFcn = createCallbackFcn(app, @dynamicsEqnSelect, true);
            app.LHSDropDown_Dyn.Value = {};
            app.LHSDropDown_BC = uidropdown(app.SelectanequationtypeandthenselecttheequationPanel);
            app.LHSDropDown_BC.Items = {};
            app.LHSDropDown_BC.DropDownOpeningFcn = createCallbackFcn(app, @BCDropOpen, true);
            app.LHSDropDown_BC.Value = {};
            app.LHSDropDown_output = uidropdown(app.SelectanequationtypeandthenselecttheequationPanel);
            app.LHSDropDown_output.Items = {};
            app.LHSDropDown_output.DropDownOpeningFcn = createCallbackFcn(app, @OutputDropOpen, true);
            app.LHSDropDown_output.Value = {};
            app.ButtonGroup = uibuttongroup(app.SelectanequationtypeandthenselecttheequationPanel);
            app.ButtonGroup.SelectionChangedFcn = createCallbackFcn(app, @selectEquation2Add, true);
            app.DynamicsButton = uitogglebutton(app.ButtonGroup);
            app.DynamicsButton.Text = 'Dynamics';
            app.DynamicsButton.Value = true;
            app.OutputButton = uitogglebutton(app.ButtonGroup);
            app.OutputButton.Text = 'Output';
            app.BCButton = uitogglebutton(app.ButtonGroup);
            app.BCButton.Text = 'BC';
            app.EquationTypeLabel = uilabel(app.SelectanequationtypeandthenselecttheequationPanel);
            app.EquationTypeLabel.Text = 'Equation Type:';
            app.EquationNumberLabel = uilabel(app.SelectanequationtypeandthenselecttheequationPanel);
            app.EquationNumberLabel.Text = 'Equation Number:';
            app.SelecttermtypeandthendefinethetermPanel = uipanel(app.LeftPanel);
            app.SelecttermtypeandthendefinethetermPanel.Title = 'Select term type and then define the term - ';
            app.Coefficient = uieditfield(app.SelecttermtypeandthendefinethetermPanel, 'text');
            app.Coefficient.Tag = 'Coefficient';
            app.ProductList = uidropdown(app.SelecttermtypeandthendefinethetermPanel);
            app.ProductList.ValueChangedFcn = createCallbackFcn(app, @stateTermTypeChange, true);
            app.ProductList.Tag = 'Int_Mul_state';
            app.TermType = uidropdown(app.SelecttermtypeandthendefinethetermPanel);
            app.TermType.Items = {' ', 'Standard', 'Integral'};
            app.TermType.ValueChangedFcn = createCallbackFcn(app, @termTypeChange, true);
            app.TermType.Value = ' ';
            app.IntVariable = uidropdown(app.SelecttermtypeandthendefinethetermPanel);
            app.IntVariable.Items = {'ds', 'd\theta'};
            app.IntVariable.Tag = 'intVariable';
            app.IntVariable.Value = 'ds';
            app.Label = uilabel(app.SelecttermtypeandthendefinethetermPanel);
            app.Label.Text = '(';
            app.Label_2 = uilabel(app.SelecttermtypeandthendefinethetermPanel);
            app.Label_2.Text = ')';
            app.IndepVar = uidropdown(app.SelecttermtypeandthendefinethetermPanel);
            app.IndepVar.Items = {'s', '\theta', '0', '1'};
            app.IndepVar.Value = 's';
            app.intLowerLimit = uidropdown(app.SelecttermtypeandthendefinethetermPanel);
            app.intLowerLimit.Items = {'0', 's'};
            app.intLowerLimit.Value = '0';
            app.intUpperLimit = uidropdown(app.SelecttermtypeandthendefinethetermPanel);
            app.intUpperLimit.Items = {'s', '1'};
            app.intUpperLimit.Value = 's';
            app.derivativeOrder = uieditfield(app.SelecttermtypeandthendefinethetermPanel, 'numeric');
            app.derivativeOrder.Limits = [0 Inf];
            app.intLabel = uiimage(app.SelecttermtypeandthendefinethetermPanel);
            app.intLabel.ImageSource = 'integral_symbol.png';
            app.d_sLabel = uiimage(app.SelecttermtypeandthendefinethetermPanel);
            app.d_sLabel.ImageSource = 'partial_symbol.png';
            app.TermTypeLabel = uilabel(app.SelecttermtypeandthendefinethetermPanel);
            app.TermTypeLabel.Text = 'Term Type:';
            app.AddButton = uibutton(app.SelecttermtypeandthendefinethetermPanel, 'push');
            app.AddButton.ButtonPushedFcn = createCallbackFcn(app, @addTerm2Equation, true);
            app.AddButton.Text = 'Add';
            app.TermtobeaddedLabel = uilabel(app.SelecttermtypeandthendefinethetermPanel);
            app.TermtobeaddedLabel.Text = 'Term to be added: ';
            app.Label_3 = uilabel(app.SelecttermtypeandthendefinethetermPanel);
            app.Label_3.Text = 'Coefficient multiplying the state/input is entered in the box below';
            app.Step2SelectanequationtoaddatermLabel = uilabel(app.LeftPanel);
            app.Step2SelectanequationtoaddatermLabel.Text = 'Step 2: Select an equation to add a term';
            app.Step2aDefinetermtoaddtoequationinStep2Label = uilabel(app.LeftPanel);
            app.Step2aDefinetermtoaddtoequationinStep2Label.Text = 'Step 2a: Define term to add to equation in Step 2';
            app.Step4ParsePDEparametersLabel = uilabel(app.LeftPanel);
            app.Step4ParsePDEparametersLabel.Text = 'Step 4: Parse PDE parameters';
            app.GetPDEObjectButton = uibutton(app.LeftPanel, 'push');
            app.GetPDEObjectButton.ButtonPushedFcn = createCallbackFcn(app, @getPDEparams, true);
            app.GetPDEObjectButton.Text = 'Get PDE Object';
            app.Step3OptionalAddorRemoveBCLabel = uilabel(app.LeftPanel);
            app.Step3OptionalAddorRemoveBCLabel.Text = 'Step 3 (Optional): Add or Remove BC #';
            app.RemoveBCList = uidropdown(app.LeftPanel);
            app.RemoveBCList.Items = {};
            app.RemoveBCList.DropDownOpeningFcn = createCallbackFcn(app, @RemoveBCDropOpen, true);
            app.RemoveBCList.Value = {};
            app.RemoveBCButton = uibutton(app.LeftPanel, 'push');
            app.RemoveBCButton.ButtonPushedFcn = createCallbackFcn(app, @removeBC, true);
            app.RemoveBCButton.Tag = 'AddDynamicsTerms';
            app.RemoveBCButton.Tooltip = {''};
            app.RemoveBCButton.Text = 'Remove BC';
            app.AddnewBCButton = uibutton(app.LeftPanel, 'push');
            app.AddnewBCButton.ButtonPushedFcn = createCallbackFcn(app, @addNewBC, true);
            app.AddnewBCButton.Text = 'Add new BC';
            app.Step5ConvertPDEtoPIELabel = uilabel(app.LeftPanel);
            app.Step5ConvertPDEtoPIELabel.Text = 'Step 5: Convert PDE to PIE';
            app.ConverttoPIEButton = uibutton(app.LeftPanel, 'push');
            app.ConverttoPIEButton.ButtonPushedFcn = createCallbackFcn(app, @convert2PIE, true);
            app.ConverttoPIEButton.Text = 'Convert to PIE';
            app.CenterPanel = uipanel(app.GridLayout);
            app.Eqns = uiaxes(app.CenterPanel);
            app.Eqns.XAxisLocation = 'top';
            app.Eqns.XTick = [];
            app.Eqns.YTick = [];
            app.StatusPanel = uipanel(app.CenterPanel);
            app.StatusPanel.Title = 'Status:';
            app.StatusBox = uilabel(app.CenterPanel);
            app.RightPanel = uipanel(app.GridLayout);
            app.AddVar = uibutton(app.RightPanel, 'push');
            app.AddVar.ButtonPushedFcn = createCallbackFcn(app, @addnewVar, true);
            app.AddVar.Text = 'Add';
            app.VarType = uidropdown(app.RightPanel);
            app.VarType.Items = {'PDE State', 'ODE State', 'Disturbance', 'Input', 'Regulated Output', 'Observed Output'};
            app.VarType.Value = 'PDE State';
            app.RemoveButton = uibutton(app.RightPanel, 'push');
            app.RemoveButton.ButtonPushedFcn = createCallbackFcn(app, @removeVar, true);
            app.RemoveButton.Text = 'Remove';
            app.VarTable = uitable(app.RightPanel);
            app.VarTable.ColumnName = {''; ''};
            app.VarTable.RowName = {};
            app.VarTable.ColumnEditable = [false true];
            app.VarTable.CellEditCallback = createCallbackFcn(app, @changeDerivative, true);
            app.VarTable.CellSelectionCallback = createCallbackFcn(app, @varSelectCallback, true);
            app.UndoButton = uibutton(app.RightPanel, 'push');
            app.UndoButton.ButtonPushedFcn = createCallbackFcn(app, @undoPress, true);
            app.UndoButton.Text = 'Undo';
            app.RedoButton = uibutton(app.RightPanel, 'push');
            app.RedoButton.ButtonPushedFcn = createCallbackFcn(app, @redoPress, true);
            app.RedoButton.Text = 'Redo';
            app.Step1DefineStatesOutputsandInputsLabel = uilabel(app.RightPanel);
            app.Step1DefineStatesOutputsandInputsLabel.Text = 'Step 1: Define States, Outputs and Inputs';
            app.SavePDEorLoadpreviouslysavedPDEPanel = uipanel(app.RightPanel);
            app.SavePDEorLoadpreviouslysavedPDEPanel.Title = 'Save PDE or Load previously saved PDE:';
            app.SaveButton = uibutton(app.SavePDEorLoadpreviouslysavedPDEPanel, 'push');
            app.SaveButton.ButtonPushedFcn = createCallbackFcn(app, @saveState, true);
            app.SaveButton.Text = 'Save';
            app.LoadButton = uibutton(app.SavePDEorLoadpreviouslysavedPDEPanel, 'push');
            app.LoadButton.ButtonPushedFcn = createCallbackFcn(app, @loadState, true);
            app.LoadButton.Text = 'Load';
            app.TextArea = uitextarea(app.PIETOOLSUIFigure);
            app.TextArea.Tag = 'Dynamics';
            app.TextArea.Editable = 'off';
            app.TextArea.Visible = 'off';
            app.ContextMenu = uicontextmenu(app.PIETOOLSUIFigure);
            app.helpAddNewBC = uimenu(app.ContextMenu);
            app.helpAddNewBC.MenuSelectedFcn = createCallbackFcn(app, @helpNewBC, true);
            app.helpAddNewBC.Text = 'Help';
            % Assign app.ContextMenu
            app.intLowerLimit.ContextMenu = app.ContextMenu;
            app.intUpperLimit.ContextMenu = app.ContextMenu;
            app.RemoveBCButton.ContextMenu = app.ContextMenu;
            % Show the figure after all components are created
            app.PIETOOLSUIFigure.Visible = 'on';
        end
    end

    % App creation and deletion
    methods (Access = public)

        % Construct app
        function app = PIETOOLS_PDE_GUI

            % Create UIFigure and components
            createComponents(app)

            % Register the app with App Designer
            registerApp(app, app.PIETOOLSUIFigure)

            % Execute the startup function
            runStartupFcn(app, @InitializeGUI)

            if nargout == 0
                clear app
            end
        end

        % Code that executes before app deletion
        function delete(app)

            % Delete UIFigure when app is deleted
            delete(app.PIETOOLSUIFigure)
        end
    end
end